# Keil uVision project projet.uvproj, settings and files
target Simulation (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: projet
  c flags: Optim=1 wLevel=2
  c include: .\src\lib\cmsis;.\src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup
    ./src/startup/: system_LPC17xx.c startup_LPC17xx.s
  group Lib
    ./src/lib/cmsis/: core_cm3.c
    ./src/lib/affichage/: affichage.c lpc17xx_clkpwr.c lpc17xx_pinsel.c lpc17xx_uart.c serial_uart0_polling.c
  group Noyau
    ./src/: noyau.c initNoyau.s allocateur.s
  group Processus User
    ./src/: etape1-2.c libGestionProcessUser.c
target Flash (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: projet
  c flags: Optim=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
